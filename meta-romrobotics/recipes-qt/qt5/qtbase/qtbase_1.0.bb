PACKAGECONFIG_append = "gles2"
PACKAGECONFIG_append = "sql-lite"

IMAGE_INSTALL_append = "qtserialport"
IMAGE_INSTALL_append = "qtvirtualkeyboard"
